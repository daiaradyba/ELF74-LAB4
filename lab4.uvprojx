# Keil uVision project lab4.uvprojx, settings and files
target EK-TM4C1294XL (5060960::V5.06 update 7 (build 960)::.\ARM-Compiler5)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab4 +hex
  AfterMake: fromelf.exe --bin Objects\lab4.axf --output Objects\lab4.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99
  c include: ..\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c
    ../TivaWare_C_Series-2.2.0.295/examples/boards/ek-tm4c1294xl/blinky/: startup_rvmdk.S
  group Documentation
    ./: readme.txt
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 6.0.0
